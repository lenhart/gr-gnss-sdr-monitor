options:
  parameters:
    generate_options: qt_gui
    id: gr_receiver
    output_language: python
    title: gr_gnss_receiver
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: gnsssdr_mod_de_serializer_0
  id: gnsssdr_mod_de_serializer
  parameters:
    monitor_port: '1234'
    pvt_monitor: '1233'
  states: {}
- name: qtgui_edit_box_msg_0
  id: qtgui_edit_box_msg
  parameters:
    is_pair: 'False'
    type: string
  states: {}

connections:
- [gnsssdr_mod_de_serializer_0, out, qtgui_edit_box_msg_0, val]

metadata:
  file_format: 1
