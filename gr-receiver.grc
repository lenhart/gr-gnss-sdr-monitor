options:
  parameters:
    author: m
    generate_options: no_gui
    id: gr_receiver
    output_language: python
    run_options: run
    title: gr_receiver
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: complex
  states: {}
- name: gnsssdr_mod_de_serializer_0
  id: gnsssdr_mod_de_serializer
  parameters:
    port: '1234'
  states: {}

connections:
- [gnsssdr_mod_de_serializer_0, '0', blocks_null_sink_0, '0']

metadata:
  file_format: 1
